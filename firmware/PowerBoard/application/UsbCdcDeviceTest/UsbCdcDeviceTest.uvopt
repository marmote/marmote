<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_opt.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp</CppX>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>UsbCdcDeviceTest</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>16000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>1</RunSim>
        <RunTarget>0</RunTarget>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <Books>
        <Book>
          <Number>0</Number>
          <Title>Reference Manual</Title>
          <Path>DATASHTS\ST\STM32F10xxx.PDF</Path>
        </Book>
      </Books>
      <DllOpt>
        <SimDllName>SARMCM3.DLL</SimDllName>
        <SimDllArguments></SimDllArguments>
        <SimDlgDllName>DARMSTM.DLL</SimDlgDllName>
        <SimDlgDllArguments>-pSTM32F102CB</SimDlgDllArguments>
        <TargetDllName>SARMCM3.DLL</TargetDllName>
        <TargetDllArguments></TargetDllArguments>
        <TargetDlgDllName>TARMSTM.DLL</TargetDlgDllName>
        <TargetDlgDllArguments>-pSTM32F102CB</TargetDlgDllArguments>
      </DllOpt>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>0</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <nTsel>1</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\UL2CM3.DLL</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(1007=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(1009=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name>(105=-1,-1,-1,-1,0)(106=165,201,921,504,0)(107=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>-UV0806MBE -O718 -S0 -C0 -N00("ARM CoreSight SW-DP") -D00(1BA01477) -L00(0) -TO18 -TC10000000 -TP21 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD20000000 -FC800 -FN1 -FF0STM32F10x_128 -FS08000000 -FL020000</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>152</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>0</Address>
          <ByteObject>0</ByteObject>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>0</BreakIfRCount>
          <Filename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\source\usb_endp.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression></Expression>
        </Bp>
      </Breakpoint>
      <WatchWindow1>
        <Ww>
          <count>0</count>
          <WinNumber>1</WinNumber>
          <ItemText>ctr</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>1</WinNumber>
          <ItemText>USB_Rx_Length

</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>1</WinNumber>
          <ItemText>USB_Rx_Buffer

,0x0A</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>1</WinNumber>
          <ItemText>wIstr</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>1</WinNumber>
          <ItemText>bDeviceState</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>1</WinNumber>
          <ItemText>\\UsbCdcDeviceTest\source/main.c\USB_Tx_Request</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>1</WinNumber>
          <ItemText>USB_Tx_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>1</WinNumber>
          <ItemText>USB_Tx_Length</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>1</WinNumber>
          <ItemText>USB_Tx_Request</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>1</WinNumber>
          <ItemText>i</ItemText>
        </Ww>
      </WatchWindow1>
      <WatchWindow2>
        <Ww>
          <count>0</count>
          <WinNumber>2</WinNumber>
          <ItemText>CMD_Rx_Length</ItemText>
        </Ww>
        <Ww>
          <count>1</count>
          <WinNumber>2</WinNumber>
          <ItemText>CMD_Rx_Buffer</ItemText>
        </Ww>
        <Ww>
          <count>2</count>
          <WinNumber>2</WinNumber>
          <ItemText>CMD_List</ItemText>
        </Ww>
        <Ww>
          <count>3</count>
          <WinNumber>2</WinNumber>
          <ItemText>i</ItemText>
        </Ww>
        <Ww>
          <count>4</count>
          <WinNumber>2</WinNumber>
          <ItemText>j</ItemText>
        </Ww>
        <Ww>
          <count>5</count>
          <WinNumber>2</WinNumber>
          <ItemText>volt</ItemText>
        </Ww>
        <Ww>
          <count>6</count>
          <WinNumber>2</WinNumber>
          <ItemText>temp</ItemText>
        </Ww>
        <Ww>
          <count>7</count>
          <WinNumber>2</WinNumber>
          <ItemText>data</ItemText>
        </Ww>
        <Ww>
          <count>8</count>
          <WinNumber>2</WinNumber>
          <ItemText>data
</ItemText>
        </Ww>
        <Ww>
          <count>9</count>
          <WinNumber>2</WinNumber>
          <ItemText>address</ItemText>
        </Ww>
        <Ww>
          <count>10</count>
          <WinNumber>2</WinNumber>
          <ItemText>pg</ItemText>
        </Ww>
      </WatchWindow2>
      <MemoryWindow1>
        <Mm>
          <WinNumber>1</WinNumber>
          <SubType>0</SubType>
          <ItemText>0x20000000</ItemText>
        </Mm>
      </MemoryWindow1>
      <DebugFlag>
        <trace>0</trace>
        <periodic>1</periodic>
        <aLwin>0</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <SystemViewers>
        <Entry>
          <Name>System Viewer\GPIOA</Name>
          <WinId>35902</WinId>
        </Entry>
        <Entry>
          <Name>System Viewer\GPIOB</Name>
          <WinId>35901</WinId>
        </Entry>
        <Entry>
          <Name>System Viewer\GPIOC</Name>
          <WinId>35900</WinId>
        </Entry>
        <Entry>
          <Name>System Viewer\NVIC</Name>
          <WinId>35903</WinId>
        </Entry>
        <Entry>
          <Name>System Viewer\RCC</Name>
          <WinId>35904</WinId>
        </Entry>
        <Entry>
          <Name>System Viewer\TIM2</Name>
          <WinId>35905</WinId>
        </Entry>
      </SystemViewers>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>Application</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>104</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>46</TopLine>
      <CurrentLine>57</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>1</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>32</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>319</TopLine>
      <CurrentLine>326</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_prop.c</PathWithFileName>
      <FilenameWithoutPath>usb_prop.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>23</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>4</TopLine>
      <CurrentLine>13</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_desc.c</PathWithFileName>
      <FilenameWithoutPath>usb_desc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>3</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>53</TopLine>
      <CurrentLine>71</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_endp.c</PathWithFileName>
      <FilenameWithoutPath>usb_endp.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>13</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>12</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_istr.c</PathWithFileName>
      <FilenameWithoutPath>usb_istr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>15</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>118</TopLine>
      <CurrentLine>118</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_pwr.c</PathWithFileName>
      <FilenameWithoutPath>usb_pwr.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>128</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>43</TopLine>
      <CurrentLine>43</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>.\source\usb_fs.c</PathWithFileName>
      <FilenameWithoutPath>usb_fs.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>CMSIS</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>2</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>12</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>389</TopLine>
      <CurrentLine>419</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\CMSIS\source\system_stm32f10x.c</PathWithFileName>
      <FilenameWithoutPath>system_stm32f10x.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Startup</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>3</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>45</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>114</TopLine>
      <CurrentLine>137</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\CMSIS\source\arm\startup_stm32f10x_md.s</PathWithFileName>
      <FilenameWithoutPath>startup_stm32f10x_md.s</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Board</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>44</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>40</TopLine>
      <CurrentLine>44</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\board\source\power_board.c</PathWithFileName>
      <FilenameWithoutPath>power_board.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>11</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>72</TopLine>
      <CurrentLine>86</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\board\source\power_control.c</PathWithFileName>
      <FilenameWithoutPath>power_control.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
      <FileNumber>12</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>21</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>197</TopLine>
      <CurrentLine>217</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\board\source\power_monitor.c</PathWithFileName>
      <FilenameWithoutPath>power_monitor.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>USB</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>13</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>31</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1</TopLine>
      <CurrentLine>1</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_init.c</PathWithFileName>
      <FilenameWithoutPath>usb_init.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>14</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>5</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>43</TopLine>
      <CurrentLine>43</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_core.c</PathWithFileName>
      <FilenameWithoutPath>usb_core.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>15</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>9</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>66</TopLine>
      <CurrentLine>66</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_sil.c</PathWithFileName>
      <FilenameWithoutPath>usb_sil.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>16</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>5</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>497</TopLine>
      <CurrentLine>514</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_regs.c</PathWithFileName>
      <FilenameWithoutPath>usb_regs.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>17</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>29</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>53</TopLine>
      <CurrentLine>58</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_int.c</PathWithFileName>
      <FilenameWithoutPath>usb_int.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
      <FileNumber>18</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>84</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>44</TopLine>
      <CurrentLine>61</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\usb\source\usb_mem.c</PathWithFileName>
      <FilenameWithoutPath>usb_mem.c</FilenameWithoutPath>
    </File>
  </Group>

  <Group>
    <GroupName>Peripheral</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>19</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\stm32f10x_gpio.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_gpio.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>20</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\stm32f10x_rcc.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_rcc.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>21</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>1141</TopLine>
      <CurrentLine>1141</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\stm32f10x_i2c.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_i2c.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>22</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\stm32f10x_spi.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_spi.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>23</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>0</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>0</TopLine>
      <CurrentLine>0</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\stm32f10x_tim.c</PathWithFileName>
      <FilenameWithoutPath>stm32f10x_tim.c</FilenameWithoutPath>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
      <FileNumber>24</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <Focus>0</Focus>
      <ColumnNumber>28</ColumnNumber>
      <tvExpOptDlg>0</tvExpOptDlg>
      <TopLine>182</TopLine>
      <CurrentLine>199</CurrentLine>
      <bDave2>0</bDave2>
      <PathWithFileName>..\..\library\peripheral\source\misc.c</PathWithFileName>
      <FilenameWithoutPath>misc.c</FilenameWithoutPath>
    </File>
  </Group>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_prop.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>21</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\library\usb\include\usb_def.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\library\usb\include\usb_regs.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_conf.h</PathWithFilename>
    <TopLine>159</TopLine>
    <CurrentLine>159</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_desc.h</PathWithFilename>
    <TopLine>15</TopLine>
    <CurrentLine>31</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\library\usb\include\usb_int.h</PathWithFilename>
    <TopLine>1</TopLine>
    <CurrentLine>1</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_istr.h</PathWithFilename>
    <TopLine>83</TopLine>
    <CurrentLine>83</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_pwr.h</PathWithFilename>
    <TopLine>23</TopLine>
    <CurrentLine>31</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <AlienFiles>
    <PathWithFilename>D:\work\software\PowerBoard\application\UsbCdcDeviceTest\include\usb_fs.h</PathWithFilename>
    <TopLine>19</TopLine>
    <CurrentLine>36</CurrentLine>
    <Constant>0</Constant>
    <WindowPosition>
      <length>0</length>
      <flags>0</flags>
      <showCmd>0</showCmd>
      <MinPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MinPosition>
      <MaxPosition>
        <xPos>0</xPos>
        <yPos>0</yPos>
      </MaxPosition>
      <NormalPosition>
        <Top>0</Top>
        <Left>0</Left>
        <Right>0</Right>
        <Bottom>0</Bottom>
      </NormalPosition>
    </WindowPosition>
  </AlienFiles>

  <MDIGroups>
    <Orientation>1</Orientation>
    <ActiveMDIGroup>0</ActiveMDIGroup>
    <MDIGroup>
      <Size>100</Size>
      <ActiveTab>0</ActiveTab>
      <Documents>
        <Doc>
          <Name>.\include\usb_fs.h</Name>
          <ColumnNumber>35</ColumnNumber>
          <TopLine>19</TopLine>
          <CurrentLine>36</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\source\usb_desc.c</Name>
          <ColumnNumber>23</ColumnNumber>
          <TopLine>4</TopLine>
          <CurrentLine>13</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\source\usb_prop.c</Name>
          <ColumnNumber>32</ColumnNumber>
          <TopLine>319</TopLine>
          <CurrentLine>326</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\source\usb_endp.c</Name>
          <ColumnNumber>3</ColumnNumber>
          <TopLine>53</TopLine>
          <CurrentLine>71</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\include\usb_prop.h</Name>
          <ColumnNumber>17</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>21</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\source\usb_fs.c</Name>
          <ColumnNumber>128</ColumnNumber>
          <TopLine>43</TopLine>
          <CurrentLine>43</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\source\main.c</Name>
          <ColumnNumber>104</ColumnNumber>
          <TopLine>46</TopLine>
          <CurrentLine>57</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\library\usb\include\usb_def.h</Name>
          <ColumnNumber>102</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\library\usb\include\usb_regs.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\include\usb_conf.h</Name>
          <ColumnNumber>25</ColumnNumber>
          <TopLine>159</TopLine>
          <CurrentLine>159</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\include\usb_desc.h</Name>
          <ColumnNumber>8</ColumnNumber>
          <TopLine>15</TopLine>
          <CurrentLine>31</CurrentLine>
        </Doc>
        <Doc>
          <Name>..\..\library\usb\include\usb_int.h</Name>
          <ColumnNumber>0</ColumnNumber>
          <TopLine>1</TopLine>
          <CurrentLine>1</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\include\usb_istr.h</Name>
          <ColumnNumber>7</ColumnNumber>
          <TopLine>83</TopLine>
          <CurrentLine>83</CurrentLine>
        </Doc>
        <Doc>
          <Name>.\include\usb_pwr.h</Name>
          <ColumnNumber>11</ColumnNumber>
          <TopLine>23</TopLine>
          <CurrentLine>31</CurrentLine>
        </Doc>
      </Documents>
    </MDIGroup>
  </MDIGroups>

</ProjectOpt>
