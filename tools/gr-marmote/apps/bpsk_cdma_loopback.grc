<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bpsk_cdma_loopback</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.pmt_intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>marmote_cdma_packet_source</key>
<param><key>id</key><value>marmote_cdma_packet_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>payload_len</key><value>32</value></param>
</block>
<block>
<key>marmote_pn_spreader_f</key>
<param><key>id</key><value>marmote_pn_spreader_f_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>preamble_len</key><value>4</value></param>
<param><key>seed</key><value>0x01</value></param>
<param><key>mask</key><value>0x00</value></param>
<param><key>spread_factor</key><value>16</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_out.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>marmote_cdma_packet_source_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_source_0</source_block_id><sink_block_id>marmote_pn_spreader_f_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_pn_spreader_f_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
