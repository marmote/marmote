<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bpsk_cdma_loopback</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from math import pi, e, exp</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>marmote_cdma_packet_framer</key>
<param><key>id</key><value>marmote_cdma_packet_framer_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>shr_len</key><value>preamble_length</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interp</key><value>oversample_factor</value></param>
</block>
<block>
<key>digital_diff_encoder_bb</key>
<param><key>id</key><value>digital_diff_encoder_bb_0</value></param>
<param><key>modulus</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>float</value></param>
<param><key>symbol_table</key><value>[1, -1]</value></param>
<param><key>dimension</key><value>1</value></param>
</block>
<block>
<key>marmote_message_source</key>
<param><key>id</key><value>marmote_message_source_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>msg_interval</key><value>1</value></param>
<param><key>msg_length</key><value>payload_length</value></param>
<param><key>node_id</key><value>1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>const_source_x</key>
<param><key>id</key><value>const_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>0</value></param>
</block>
<block>
<key>marmote_pn_spreader_b</key>
<param><key>id</key><value>marmote_pn_spreader_b_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x492</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversample_factor</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>marmote_pn_despreader_cc</key>
<param><key>id</key><value>marmote_pn_despreader_cc_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x492</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>preamble_length</key><value>preamble_length</value></param>
<param><key>payload_length</key><value>payload_length</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/5</value></param>
<param><key>alpha</key><value>0.50</value></param>
<param><key>ntaps</key><value>31</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1_0</value></param>
</block>
<block>
<key>marmote_pn_despreader_cc</key>
<param><key>id</key><value>marmote_pn_despreader_cc_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x492</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>preamble_length</key><value>preamble_length</value></param>
<param><key>payload_length</key><value>payload_length</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0_1_1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_2</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_sync_cmp.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_1_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_dspr_out.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_sync_filt.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_1_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_dspr_fixed.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_sync_fixed.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_1</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_sync_factor.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/dbpsk2.dat</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>marmote_pn_synchronizer_cc</key>
<param><key>id</key><value>marmote_pn_synchronizer_cc_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x492</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>threshold_factor_rise</key><value>30</value></param>
<param><key>look_ahead</key><value>spread_factor*oversample_factor*2</value></param>
<param><key>alpha</key><value>0.01</value></param>
<param><key>avg_min</key><value>0.1</value></param>
<param><key>offset</key><value>0x00</value></param>
</block>
<block>
<key>marmote_pn_synchronizer</key>
<param><key>id</key><value>marmote_pn_synchronizer_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x492</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>threshold_factor_rise</key><value>3200</value></param>
<param><key>look_ahead</key><value>10</value></param>
<param><key>alpha</key><value>0.01</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>e**(1j*3*pi/8)*1 + 0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_length</value></param>
<param><key>value</key><value>16</value></param>
</block>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>marmote_pn_synchronizer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_cc_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_cc_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_diff_encoder_bb_0</source_block_id><sink_block_id>marmote_pn_spreader_b_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_framer_0</source_block_id><sink_block_id>digital_diff_encoder_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_framer_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_spreader_b_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_message_source_0</source_block_id><sink_block_id>marmote_cdma_packet_framer_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>const_source_x_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>marmote_pn_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_cc_0</source_block_id><sink_block_id>marmote_pn_despreader_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_cc_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_cc_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>marmote_pn_despreader_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_cc_0_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_cc_0_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1</source_block_id><sink_block_id>blocks_file_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0_1_1</source_block_id><sink_block_id>blocks_file_sink_0_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_cc_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_float_to_complex_0_1_1</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
