<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.pmt_intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>marmote_cdma_packet_source</key>
<param><key>id</key><value>marmote_cdma_packet_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>preamble_length</key><value>4</value></param>
<param><key>payload_length</key><value>8</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>marmote_cdma_packet_source_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_source_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
</flow_graph>
