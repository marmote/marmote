<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bpsk_cdma_loopback</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_filt_out.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.pmt_intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>marmote_pn_spreader_f</key>
<param><key>id</key><value>marmote_pn_spreader_f_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>marmote_pn_despreader</key>
<param><key>id</key><value>marmote_pn_despreader_0</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>seed_offset</key><value>preamble_length*spread_factor</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>marmote_cdma_packet_source</key>
<param><key>id</key><value>marmote_cdma_packet_source_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_out.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Synchronizer Tag Debugger</value></param>
</block>
<block>
<key>marmote_pn_synchronizer</key>
<param><key>id</key><value>marmote_pn_synchronizer_0</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_length</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>marmote_cdma_packet_source_1</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_source_1</source_block_id><sink_block_id>marmote_pn_spreader_f_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_spreader_f_1</source_block_id><sink_block_id>marmote_pn_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>marmote_pn_despreader_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
</flow_graph>
