<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>bpsk_cdma_loopback</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_filt_out_0.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>marmote_pn_despreader</key>
<param><key>id</key><value>marmote_pn_despreader_0</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>seed_offset</key><value>preamble_length*spread_factor</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_length</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.pmt_from_long(0)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.pmt_from_long(1)</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>0</value></param>
</block>
<block>
<key>marmote_pn_synchronizer</key>
<param><key>id</key><value>marmote_pn_synchronizer_0</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>marmote_pn_spreader_f</key>
<param><key>id</key><value>marmote_pn_spreader_f_1</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x12</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_length</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>marmote_cdma_packet_source</key>
<param><key>id</key><value>marmote_cdma_packet_source_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>0</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
</block>
<block>
<key>marmote_cdma_packet_source</key>
<param><key>id</key><value>marmote_cdma_packet_source_0_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>1</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>value</key><value>8</value></param>
</block>
<block>
<key>marmote_pn_spreader_f</key>
<param><key>id</key><value>marmote_pn_spreader_f_1_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x14</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>marmote_pn_synchronizer</key>
<param><key>id</key><value>marmote_pn_synchronizer_0_0</value></param>
<param><key>reverse</key><value>True</value></param>
<param><key>mask</key><value>0x14</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>marmote_pn_despreader</key>
<param><key>id</key><value>marmote_pn_despreader_0_0</value></param>
<param><key>mask</key><value>0x14</value></param>
<param><key>seed</key><value>0x10</value></param>
<param><key>seed_offset</key><value>preamble_length*spread_factor</value></param>
<param><key>payload_len</key><value>payload_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_filt_out_1.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>node_id</key><value>1</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_0_0_0</value></param>
<param><key>file</key><value>/home/nest/Projects/gr-marmote/apps/pn_throttle_in.dat</value></param>
<param><key>type</key><value>float</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>1</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e5</value></param>
</block>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>marmote_pn_despreader_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0</source_block_id><sink_block_id>blocks_file_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>marmote_cdma_packet_source_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_source_0</source_block_id><sink_block_id>marmote_pn_spreader_f_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>marmote_cdma_packet_source_0_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_cdma_packet_source_0_0</source_block_id><sink_block_id>marmote_pn_spreader_f_1_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>marmote_pn_synchronizer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_spreader_f_1</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>marmote_pn_synchronizer_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_spreader_f_1_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_despreader_0_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0_0</source_block_id><sink_block_id>marmote_pn_despreader_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>marmote_pn_synchronizer_0_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_file_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
