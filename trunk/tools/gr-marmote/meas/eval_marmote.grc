<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>eval_marmote</value></param>
<param><key>author</key><value>Sandor Szilvasi</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_length</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>oversample_factor</value></param>
<param><key>value</key><value>5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>10e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>total_packets</value></param>
<param><key>value</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_length</value></param>
<param><key>value</key><value>8*2</value></param>
</block>
<block>
<key>marmote_cdma_packet_sink</key>
<param><key>id</key><value>marmote_cdma_packet_sink_0_0_1_0_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>node_id</key><value>5</value></param>
<param><key>total_pkt</key><value>total_packets</value></param>
</block>
<block>
<key>dsss_pn_despreader_cc</key>
<param><key>id</key><value>dsss_pn_despreader_cc_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>mask</key><value>0x606</value></param>
<param><key>seed</key><value>0x401</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>preamble_length</key><value>preamble_length</value></param>
<param><key>payload_length</key><value>payload_length</value></param>
</block>
<block>
<key>dsss_packet_deframer</key>
<param><key>id</key><value>dsss_packet_deframer_0_0</value></param>
<param><key>debug</key><value>False</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_2_1_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>1000000000</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>2405.001e6</value></param>
<param><key>gain0</key><value>25</value></param>
<param><key>ant0</key><value>RX2</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0_1_0_0_1</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/sszilvasi/gr-marmote/meas/mm_tmp.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>unbuffered</key><value>True</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>/home/sszilvasi/meas/marmote/20130909-rc-field-north/140.dat</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>"" + filename</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>label</key><value>Spread factor</value></param>
<param><key>value</key><value>8</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>threshold</value></param>
<param><key>label</key><value>Acquisition threshold</value></param>
<param><key>value</key><value>0.5</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>t</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rrc_alpha</value></param>
<param><key>label</key><value>RRC filter alpha</value></param>
<param><key>value</key><value>0.125</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>a</value></param>
</block>
<block>
<key>dsss_pn_acquisition_cc</key>
<param><key>id</key><value>dsss_pn_acquisition_cc_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>preamble_len</key><value>preamble_length</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
<param><key>oversample_factor</key><value>oversample_factor</value></param>
<param><key>pn_mask</key><value>0x606</value></param>
<param><key>pn_seed</key><value>0x401</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>sym_rate</key><value>samp_rate/5</value></param>
<param><key>alpha</key><value>rrc_alpha</value></param>
<param><key>ntaps</key><value>31</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>label</key><value>Input filename</value></param>
<param><key>value</key><value>mm_tmp</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0_1_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_pn_acquisition_cc_0</source_block_id><sink_block_id>dsss_pn_despreader_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_pn_despreader_cc_0</source_block_id><sink_block_id>dsss_packet_deframer_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dsss_pn_despreader_cc_0</source_block_id><sink_block_id>blocks_null_sink_1_2_1_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_packet_deframer_0_0</source_block_id><sink_block_id>marmote_cdma_packet_sink_0_0_1_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>dsss_pn_acquisition_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>dsss_pn_acquisition_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
