# Keil uVision project UsbCdcDeviceTest.uvproj, settings and files
target UsbCdcDeviceTest (ARM-ADS)
  device: STM32F102CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UsbCdcDeviceTest
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .\include;..\..\library\CMSIS\include;..\..\library\peripheral\include;..\..\library\board\include;..\..\library\usb\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./source/: main.c usb_prop.c usb_desc.c usb_endp.c usb_istr.c usb_pwr.c usb_fs.c
  group CMSIS
    ../../library/CMSIS/source/: system_stm32f10x.c
  group Startup
    ../../library/CMSIS/source/arm/: startup_stm32f10x_md.s
  group Board
    ../../library/board/source/: power_board.c power_control.c power_monitor.c m6_rf315.c
  group USB
    ../../library/usb/source/: usb_init.c usb_core.c usb_sil.c usb_regs.c usb_int.c usb_mem.c
  group Peripheral
    ../../library/peripheral/source/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_spi.c stm32f10x_tim.c misc.c
