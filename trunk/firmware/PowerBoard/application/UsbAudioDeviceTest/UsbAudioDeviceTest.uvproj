# Keil uVision project UsbAudioDeviceTest.uvproj, settings and files
target UsbAudioDeviceTest (ARM-ADS)
  device: STM32F102CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: UsbAudioDeviceTest
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,HSE_VALUE=16000000
  c include: .\include;..\..\library\CMSIS\include;..\..\library\peripheral\include;..\..\library\board\include;..\..\library\usb\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./source/: hw_config.c main.c stm32f10x_it.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group CMSIS
    ../../library/CMSIS/source/: system_stm32f10x.c
  group Startup
    ../../library/CMSIS/source/arm/: startup_stm32f10x_md.s
  group Board
    ../../library/board/source/: power_board.c power_control.c power_monitor.c
  group USB
    ../../library/usb/source/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Peripheral
    ../../library/peripheral/source/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_tim.c stm32f10x_spi.c
